## drivers/net/ethernet/stmicro/stmmac/rtl8367c/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config ETHNET_RTL8367C
	tristate "ethnet rtl8367c support"
```
